# Keil uVision project Template.uvproj, settings and files
target JoystickRGB (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1115/303 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Template +hex
  c flags: Optim=1
  c include: ..\Template;.\include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: startup_LPC11xx.s system_LPC11xx.c
  group Source files
    ./src/: main.c gpio.c uart.c
